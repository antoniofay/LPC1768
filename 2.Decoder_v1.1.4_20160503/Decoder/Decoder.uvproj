# Keil uVision project Decoder.uvproj, settings and files
target MCB1700 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Decoder +hex
  c flags: Optim=1 oTime=1
  c include: ..\Library;..\Library\src;..\Library\inc
  memory RVCT4: ROM 0x2000 size 0x76000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Http Files
    ./Web/: Web.inp pg_footer.inc pg_header.inc xml_http.js index.htm network.cgi system.cgi configports.cgi update.cgi
  group Source Files
    ./: startup_LPC17xx.s Decoder.c HTTP_CGI.c
    ./Web/: Web.c
  group Audio Source
    ../Library/src/: ring.c
  group Network Configuration
    ./: Net_Config.c Net_Debug.c
  group Drivers
    ../Library/src/: system_LPC17xx.c EMAC_LPC17xx.c timer.c wdt.c gpio.c uart.c adc.c iap.c dma.c i2s.c
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib TCPD_CM3.lib
target MCB1700 Debug (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: LEDswitch
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
